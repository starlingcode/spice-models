.MODEL DI_BAT54JW D  ( IS=34.9u RS=0.210 BV=30.0 IBV=2.00u CJO=13.3p  M=0.333 N=2.28 TT=7.20n )
