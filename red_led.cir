.model RED_LED  D(IS = -9.264423085400364e-13 N = 3.2219581713051992 RS = 2.994321979978941)
