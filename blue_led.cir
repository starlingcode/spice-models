.model BLUE_LED  D(IS = -4.727445914427769e-13 N = 4.583675798761746 RS = 23.38251312494106)
